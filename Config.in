## package/test_package/Config.in
```kconfig
config BR2_PACKAGE_TEST_PACKAGE
    bool "test_package"
    help
        package for testing purposes
```
